<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\bai2_c2.ewp</path>
  </project>
  <batchBuild />
</workspace>
